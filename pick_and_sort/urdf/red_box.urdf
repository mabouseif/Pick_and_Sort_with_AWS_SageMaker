Commit message: second commit

File: pick_and_sort/urdf/red_box.urdf (robot description, URDF)
Before this commit: robot red_box, 1 links, 0 joints
Links:
- link red_box_base_link: mass 0.03 -> 0.005
